## config/boards/shields/macro/Kconfig.defconfig
```kconfig
if SHIELD_MACRO

config ZMK_KEYBOARD_NAME
    default "hmchoe's macropad"

endif
```
